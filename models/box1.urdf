Commit message: bigger plane

File: models/box1.urdf (robot description, URDF)
Before this commit: robot box1, 2 links, 1 joints
Links:
- link box1: geometry collision box size=0.5 0.5 0.15; visual box size=0.5 0.5 0.15
